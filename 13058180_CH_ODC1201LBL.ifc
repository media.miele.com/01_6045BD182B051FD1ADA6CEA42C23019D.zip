Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 4fe51eb1-2f8e-43ab-b9f4-4d4303d680b6, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-16T13:59:00+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 13058180_CH_ODC1201LBL:331J0CDL_CH_13058180_ODC1201LBL, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_ProductRequirements - Category: Specialty Equipment
Material: z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Connection_Gas
Pset_BuildingElementProxyCommon - Reference: 331J0CDL_CH_13058180_ODC1201LBL; sets with these values: 2
